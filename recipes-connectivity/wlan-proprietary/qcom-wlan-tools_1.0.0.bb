inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Qualcomm Atheros common tools"

DEPENDS += "diag libnl glib-2.0 cld80211-lib libxml2 icu"

PV = "1.0"

QCM6490_SHA256SUM = "4a8c3cdc870eae163d88698a46076dccd50b4ba900eb4d57c84679c67c446cd0"
QCS9100_SHA256SUM = "0f11e1b5feaaa06324074e426a4513ce99d5abfaa8cbb0a1f75121bf0ba932c5"
QCS8300_SHA256SUM = "b6f29103879a2703877af7191d901ad1ac1e2b6f18acf9524815546f71546afe"
QCS615_SHA256SUM = "6c4a46a687c7bdc8db18d7ea03ce75e1483fdd0049ae351658c87451ff328855"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

FILES:${PN} += " \
	/usr/bin/* \
	/usr/sbin/* \
	/usr/lib/* \
	"

