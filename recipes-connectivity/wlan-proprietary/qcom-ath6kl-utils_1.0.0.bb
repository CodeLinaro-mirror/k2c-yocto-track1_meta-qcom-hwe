inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Qualcomm Atheros ath6kl utils."

DEPENDS += "diag libnl glib-2.0"

PV = "1.0"

QCM6490_SHA256SUM = "bcc0368f61bdbac3c58b374e7774766416fca8a453cb51e4f5b43fe1e8db6d2e"
QCS9100_SHA256SUM = "c622c9dc9ad1ed7206a9e287b43338a9ba50c1277792a65ecf9525ac85f373cf"
QCS8300_SHA256SUM = "02522ade3a32991d4871f9999757e28cd3393a36fe83ac20bc40eaaaeec4693a"
QCS615_SHA256SUM = "cf6bd096d39c9098e3f75f17f77fb3628dac0467ace8170b0b4e4f807e0048b0"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
