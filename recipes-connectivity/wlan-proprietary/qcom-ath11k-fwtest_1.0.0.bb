inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Qualcomm Technologies ath11k-fwtest"

DEPENDS += "libnl"

PV = "1.0"

QCM6490_SHA256SUM = "2ee13917d6aa36e6e2943fb57bb675b90d6d53ee9e581bef8b31cd635efe9365"
QCS9100_SHA256SUM = "20442d5c446f2d3d14029fbdfcfee4ba52f6ea957ead7b76d319850382603d3e"
QCS8300_SHA256SUM = "85c61295c18eb9911df8b91ab4836ca2a0331d948e68ade29f6ea03fcd42c009"
QCS615_SHA256SUM = "f290a05e053589326a9b12c8aef92e8baf8f704f5104b2363ffc03ab7c29046f"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
