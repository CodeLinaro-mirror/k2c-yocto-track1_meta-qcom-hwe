inherit autotools-brokensep pkgconfig qprebuilt

DESCRIPTION = "Qualcomm Technologies Ctrl App Dut Tool"
LICENSE     = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DEPENDS += "libnl glib-2.0"
PV = "1.0"

QCM6490_SHA256SUM = "5e633a08204e84f2bc2af4258991ab0b8edae7962b256f4f2e7d1690e476b609"
QCS9100_SHA256SUM = "b1e0fda75b1428e341fbbf4a4c4cd6a7f7d8d46b98c376d768a6b6b25f19e5b5"
QCS8300_SHA256SUM = "56d07aed8b60305490ef43bbf891316ca00da63dfcc7ba2a6eb198cccb367872"
QCS615_SHA256SUM = "c739af6e7d6042bc34a6f99a5ecfd3d5785b0207ea804c0e9c34d12a7137ec6b"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
