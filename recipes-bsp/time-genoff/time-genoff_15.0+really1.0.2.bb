inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Time Genoff Library"

QCM6490_SHA256SUM = "1aed0a9a4f58a580cebf252818f39a57355419b25decd9b2e082f7048e2f48d8"
QCS9100_SHA256SUM = "a098fa19489ce58b64164ed009ddde535c0fcf85ed81039bfac3bfbf15dc5292"
QCS8300_SHA256SUM = "e767fc25475d7198a742d74670dedcefeb068993518cd874b96f8c9a8ae1ba08"
QCS615_SHA256SUM = "6b15f82c4cc1f8a055bc616993e5e1d03c7559d09d12eec02de78142988a0b8d"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
