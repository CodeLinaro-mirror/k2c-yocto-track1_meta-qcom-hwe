inherit qprebuilt

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Camx Autogen"

QCS9100_SHA256SUM = "0218b6d7e09ff2a8c2457799082b962f163ccb462393e2c093525ee8b4dfd7f3"
QCS8300_SHA256SUM = "e2d2bcd5a89913c7ac2fbb3e420a8211e80100b1953ccf74dec5e135cacbfa70"
QCS615_SHA256SUM = "fa02a8cc0958376a79f5af7340e2f0de873afd54a22086b8b1839e5699ecafca"

SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

