inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}/${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Securemsm headers"

QCM6490_SHA256SUM = "7b61906ffb91a63173730584cdab3be87c370ba524e0209d7c6bcccad7eb5766"
QCS9100_SHA256SUM = "3046756e9b2e5a234295c466adb6ca0b71027c1c18c7606980f60f69029af311"
QCS8300_SHA256SUM = "bf8095682070d82022aa167b9f62197c899b0777825498aa9e0c2ee55ab6b6a1"
QCS615_SHA256SUM = "c45614513853f5e160e367e9cec168a9bc9d5bcb6fdaa9f13224030c2d09b7f8"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

ALLOW_EMPTY:${PN} = "1"
